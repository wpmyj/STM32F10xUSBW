# Keil uVision project VirtualCOMPort.uvprojx, settings and files
target STM3210B-EVAL (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103VB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM3210E-EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STM3210B_EVAL
  c include: ..\include;..\..\..\APP;..\..\..\..\FWLIB\Lib\CMSIS;..\..\..\..\FWLIB\Lib\FWLib\INC;..\..\..\..\FWLIB\Lib\Startup;..\..\..\..\FWLIB\Lib\USB\INC;..\..\..\..\FWLIB\Lib\WOWLIB\INC;..\..\..\..\FWLIB\main
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group MAIN
    ../source/: main.c
    ../../../../FWLIB/main/: STM32_IT.c STM32_WOW.C
  group APP
    ../../../APP/: A3987_TEST.C ADC_Temperature.C ADC_TEST.C Buzzer_TEST.C CAN_TEST.C CD4511BM_TEST.C font.c FX2N_14MR.C LK3U_40MR.C MS0800_PC004V10.C MS0800_PL001V20.C MS0800_PM001V20.C MX25L4006E.C OLED096_TEST.C PWM_TEST.C R2A15908SP.C SPI_FLASH.C SPI_TEST.C SPItoUSART.C SSD1963.C STM32_LCD.C TEST.C TM1618.C USART_TEST.C USBtoSPI.C VirtualCom.C
  group HC
    ../../../APP/: PM001V20.C
  group 功能库
    ../../../../FWLIB/Lib/WOWLIB/SCR/: STM32_096OLED.C STM32_A3987.C STM32_ADC.C STM32_CAN.C STM32_CD4511BM.C STM32_CRC.C STM32_DAC.C STM32_DMA.C STM32_EXTI.C STM32_GPIO.C STM32_GT32L32M0180.C STM32_I2C.C STM32_NVIC.C STM32_PWM.C STM32_RCC.C STM32_RTC.C STM32_SDCard.C STM32_SPI.C STM32_SPI_Struct.C STM32_SYS.C STM32_SYSLED.C STM32_SYSTICK.C STM32_TIM.C STM32_TOOLS.C STM32_USART.C STM32_WDG.C
  group FWLib
    ../../../../FWLIB/Lib/FWLib/SCR/: stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group PHY
    ../../../../FWLIB/Lib/PHY/SD_Card/: sdcard.c
    ../../../../FWLIB/Lib/PHY/fatfs/: diskio.c ff.c
  group USB应用接口
    ../source/: hw_config.c usb_desc.c usb_istr.c usb_prop.c usb_pwr.c usb_endp.c Virtual_COM应用接口.txt
  group USB固件库
    ../../../../FWLIB/Lib/USB/SCR/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c
    ../../../../FWLIB/Lib/USB/: USB固件库.txt
  group Startup
    ../../../../FWLIB/Lib/Startup/: cortexm3_macro.s stm32f10x_vector.s
  group Doc
    ../../../../FWLIB/DOC/: C语言printf()输出格式大全.txt note.txt USB说明.txt 常用C语言标准库函数.txt
target STM3210E-EVAL (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: as above
  output: STM3210E-EVAL +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: USE_STM3210E_EVAL
  c include: ..\include;..\..\..\APP;..\..\..\..\FWLIB\Lib\FWLib\INC;..\..\..\..\FWLIB\Lib\Startup;..\..\..\..\FWLIB\Lib\USB\INC;..\..\..\..\FWLIB\Lib\WOWLIB\INC;..\..\..\..\FWLIB\main
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target TEST (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: as above
  output: TEST +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: TEST
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target R2A15908SP (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: as above
  output: VirtualCom +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: R2A15908SP
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target USART_TEST (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: as above
  output: USART_TEST +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: USART_TEST
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target SSD1963 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: as above
  output: VirtualCom +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: SSD1963
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target STM32_LCD (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: VirtualCom +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: STM32_LCD
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
target ADC_TEST (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: as above
  output: VirtualCom +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: ADC_TEST
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target ADC_Temperature (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: as above
  output: VirtualCom +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: ADC_Temperature
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target CAN_TEST (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: as above
  output: VirtualCom +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: CAN_TEST
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target SPI_TEST (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: as above
  output: SPI_TEST +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: SPI_TEST
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target SPI_FLASH (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: as above
  output: SPI_FLASH +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: SPI_FLASH
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target SPItoUSART (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: as above
  output: SPItoUSART +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: SPItoUSART
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target CD4511BM_TEST (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: as above
  output: VirtualCom +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: CD4511BM_TEST
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target MS0800_PL001V20 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: as above
  output: MS0800_PL001V20 +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: MS0800_PL001V20
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target MS0800_PC004V10 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: as above
  output: PWM_TEST +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: MS0800_PC004V10
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target MS0800_PM001V20 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: as above
  output: PWM_TEST +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: MS0800_PM001V20
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target MX25L4006E (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: as above
  output: PWM_TEST +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: MX25L4006E
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target TM1618 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: as above
  output: PWM_TEST +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: TM1618
  c include: ..\..\..\..\FWLIB\Lib\CMSIS;..\..\..\..\FWLIB\Lib\FWLib\INC;..\..\..\..\FWLIB\Lib\Startup;..\..\..\..\FWLIB\Lib\USB\INC;..\..\..\..\FWLIB\Lib\WOWLIB\INC;..\include;..\..\..\APP;..\..\..\..\FWLIB\main
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target VirtualCom (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: as above
  output: PWM_TEST +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: VirtualCom
  c include: ..\..\..\FWLIB\Lib\CMSIS;..\..\..\..\FWLIB\Lib\FWLib\INC;..\..\..\FWLIB\Lib\Startup;..\..\..\..\FWLIB\Lib\USB\INC;..\..\..\APP;..\..\..\..\FWLIB\Lib\PHY\SD_Card;..\..\..\..\FWLIB\Lib\PHY\fatfs;..\..\..\..\FWLIB\Lib\WOWLIB\INC;..\..\..\..\FWLIB\main;..\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target USBtoSPI (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: as above
  output: USBtoSPI +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: USBtoSPI
  c include: ..\include;..\..\..\APP;..\..\..\..\FWLIB\Lib\CMSIS;..\..\..\..\FWLIB\Lib\FWLib\INC;..\..\..\..\FWLIB\Lib\PHY\fatfs;..\..\..\..\FWLIB\Lib\PHY\SD_Card;..\..\..\..\FWLIB\Lib\Startup;..\..\..\..\FWLIB\Lib\USB\INC;..\..\..\..\FWLIB\Lib\WOWLIB\INC;..\..\..\..\FWLIB\main
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target PWM_TEST (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: as above
  output: PWM_TEST +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: PWM_TEST
  c include: ..\include;..\..\..\..\FWLIB\Lib\CMSIS;..\..\..\..\FWLIB\Lib\FWLib\INC;..\..\..\..\FWLIB\Lib\PHY\fatfs;..\..\..\..\FWLIB\Lib\PHY\SD_Card;..\..\..\..\FWLIB\Lib\Startup;..\..\..\..\FWLIB\Lib\USB\INC;..\..\..\..\FWLIB\Lib\WOWLIB\INC;..\..\..\..\FWLIB\main;..\..\..\APP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target OLED096_TEST (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: as above
  output: OLED096_TEST +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: OLED096_TEST
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target LK3U_40MR (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: as above
  output: LK3U_40MR +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: LK3U_40MR
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target FX2N_14MR (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: as above
  output: FX2N_14MR +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: FX2N_14MR
  c include: ..\include;..\..\..\APP;..\..\..\..\FWLIB\Lib\CMSIS;..\..\..\..\FWLIB\Lib\FWLib\INC;..\..\..\..\FWLIB\Lib\Startup;..\..\..\..\FWLIB\Lib\PHY;..\..\..\..\FWLIB\Lib\Startup;..\..\..\..\FWLIB\Lib\USB\INC;..\..\..\..\FWLIB\Lib\WOWLIB\INC;..\..\..\..\FWLIB\main
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target A3987_TEST (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: as above
  output: SPI_FLASH +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: A3987_TEST
  c include: ..\include;..\..\..\APP;..\..\..\..\FWLIB\Lib\CMSIS;..\..\..\..\FWLIB\Lib\FWLib\INC;..\..\..\..\FWLIB\Lib\PHY;..\..\..\..\FWLIB\Lib\Startup;..\..\..\..\FWLIB\Lib\USB\INC;..\..\..\..\FWLIB\Lib\WOWLIB\INC;..\..\..\..\FWLIB\main
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target Buzzer_TEST (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: as above
  output: Buzzer_TEST +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: Buzzer_TEST
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target PM001V20 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: as above
  output: PM001V20 +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: PM001V20
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
software components: CMSIS:CORE 4.2.0
